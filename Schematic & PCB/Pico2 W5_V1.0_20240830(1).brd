# Repository Elecrow-RD/Elecrow-RP2350-Pico-W5-Board

## EAGLE design Schematic & PCB/Pico2 W5_V1.0_20240830(1).brd

Parts:
BOOT: TS3425BA; SMD_KEY4.2*3.*.2.5
C1, C2: 15pF; 0201_W
C3, C18: 225; 0201_W
C4, C17, C25, C26: 475; 0201_W
C5, C6, C7, C9, C11, C12, C13, C14, C15, C16, C20, C21, C22, C24: 104; 0201_W
C8, C10: 10uf; 0402
C19: 105; 0201_W
D1: MBR120LSF; SOD123
D3: MHT192UGCT绿色; DISCRETE_D0603
L1: 3.3uH; SMD,1.6X2MM
P1, P2, P3: TP; CROWPICO_W_PAD-1P
PICO-W: CROWPICO-W
R1, R5, R13: 10K; 0201_W
R2, R7, R8: 1K; 0201_W
R3, R4: 5.1K; 0201_W
R6: 0R/NC; 0201_W
R9: 680R; 0201_W
R10, R11: 27.4R; 0201_W
R12: 200R; 0201_W
R14: 100K; 0201_W
R15: 1R; 0201_W
R16: 33R; 0201_W
RESET: TS3425BA; SMD_KEY4.2*3.*.2.5
RX: TP; TP2
SWD: PIND2.0-3P; HDR2.0-3P
TX: TP; TP2
TYPE-C1: TYPE-C16PIN; TYPE-C16PIN2MD(073)
U1: RP2350A; QFN-60_7X7MM
U2: BW16(4M)板载天线; BW16
U3: W25Q64JVXGIQ; W25QXX-XSON-8-EP(4X4)
U4: RT9013_33GB; SOT23-5_W
X1: X322512MSB4SI; A_XBJ_SMD3225

Connections:
3V3_EN: PICO-W.37-1, PICO-W.37-2, PICO-W.37-3, PICO-W.37-4, R14.1, U4.3 (EN)
+1V1: C4.1, C15.1, C24.1, C26.1, L1.P$1 (1), U1.P$6 (DVDD2), U1.P$23 (DVDD1), U1.P$39 (DVDD0), U1.P$50 (VREG_FB)
+3V3: C6.2, C7.1, C10.2, C11.2, C12.1, C13.1, C16.1, C18.1, C19.2, C20.1, C21.1, C22.1, C25.1, PICO-W.36-1, PICO-W.36-2, PICO-W.36-3, PICO-W.36-4, R1.2, R5.2, R12.2, R13.2, R16.2, U1.P$1 (IOVDD5), U1.P$11 (IOVDD4), U1.P$20 (IOVDD3), U1.P$30 (IOVDD2), U1.P$38 (IOVDD1), U1.P$45 (IOVDD0), U1.P$49 (VREG_VIN), U1.P$53 (USB_OTP_VDD), U1.P$54 (QSPI_IOVDD), U2.8 (3V3_VDD), U3.8 (VCC), U4.5 (VOUT)
ADC_VREF: PICO-W.35-1, PICO-W.35-2, PICO-W.35-3, PICO-W.35-4, R12.1, R15.2
BOOT: BOOT.P$1 (1), P3.P$1, R2.2
GND: BOOT.P$4 (4), C1.2, C2.1, C3.2, C4.2, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C19.1, C20.2, C21.2, C22.2, C24.2, C25.2, C26.2, D3.-, PICO-W.3-1, PICO-W.3-2, PICO-W.3-3, PICO-W.3-4, PICO-W.8-1, PICO-W.8-2, PICO-W.8-3, PICO-W.8-4, PICO-W.13-1, PICO-W.13-2, PICO-W.13-3, PICO-W.13-4, PICO-W.18-1, PICO-W.18-2, PICO-W.18-3, PICO-W.18-4, PICO-W.23-1, PICO-W.23-2, PICO-W.23-3, PICO-W.23-4, PICO-W.28-1, PICO-W.28-2, PICO-W.28-3, PICO-W.28-4, PICO-W.33-1, PICO-W.33-2, PICO-W.33-3, PICO-W.33-4, PICO-W.38-1, PICO-W.38-2, PICO-W.38-3, PICO-W.38-4, R3.2, R4.1, R7.1, RESET.P$3 (3), SWD.P$2, TYPE-C1.A1 (GND), TYPE-C1.A12 (GND), TYPE-C1.B1 (GND), TYPE-C1.B12 (GND), TYPE-C1.P$1, TYPE-C1.P$2, TYPE-C1.P$3, TYPE-C1.P$4, U1.P$47 (VREG_PGND), U1.P$61 (GND), U2.9 (GND), U2.17 (GND17), U3.4 (GND), U3.EP (GND), U4.2 (GND), X1.2 (GND)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
GP0/UART0_TX: PICO-W.1-1, PICO-W.1-2, PICO-W.1-3, PICO-W.1-4, U1.P$2 (GPIO0)
GP1/UART0_RX: PICO-W.2-1, PICO-W.2-2, PICO-W.2-3, PICO-W.2-4, U1.P$3 (GPIO1)
GP2/I2C1_SDA: PICO-W.4-1, PICO-W.4-2, PICO-W.4-3, PICO-W.4-4, U1.P$4 (GPIO2)
GP3/I2C1_SCL: PICO-W.5-1, PICO-W.5-2, PICO-W.5-3, PICO-W.5-4, U1.P$5 (GPIO3)
GP4/UART1_TX: U1.P$7 (GPIO4), U2.15 (GPIOB_2)
GP5/UART1_RX: U1.P$8 (GPIO5), U2.16 (GPIOB_1)
GP6/SPI_CLK/SD_CLK: PICO-W.9-1, PICO-W.9-2, PICO-W.9-3, PICO-W.9-4, U1.P$9 (GPIO6)
GP7/SPI_MOSI/SD_SDI: PICO-W.10-1, PICO-W.10-2, PICO-W.10-3, PICO-W.10-4, U1.P$10 (GPIO7)
GP16/SPI_MISO/SD_SDO: PICO-W.21-1, PICO-W.21-2, PICO-W.21-3, PICO-W.21-4, U1.P$27 (GPIO16)
GP17/SD_CS/SPI_CS2: PICO-W.22-1, PICO-W.22-2, PICO-W.22-3, PICO-W.22-4, U1.P$28 (GPIO17)
GP26*I2C1_SDA: PICO-W.31-1, PICO-W.31-2, PICO-W.31-3, PICO-W.31-4, U1.P$40 (GPIO26_ADC0)
GP27*I2C1_SCL: PICO-W.32-1, PICO-W.32-2, PICO-W.32-3, PICO-W.32-4, U1.P$41 (GPIO27_ADC1)
GP28-ADC2: PICO-W.34-1, PICO-W.34-2, PICO-W.34-3, PICO-W.34-4, U1.P$42 (GPIO28_ADC2)
GP29-ADC3: U1.P$43 (GPIO29_ADC3)
GPIO8: PICO-W.11-1, PICO-W.11-2, PICO-W.11-3, PICO-W.11-4, U1.P$12 (GPIO8)
GPIO9: PICO-W.12-1, PICO-W.12-2, PICO-W.12-3, PICO-W.12-4, U1.P$13 (GPIO9)
GPIO10: PICO-W.14-1, PICO-W.14-2, PICO-W.14-3, PICO-W.14-4, U1.P$14 (GPIO10)
GPIO11: PICO-W.15-1, PICO-W.15-2, PICO-W.15-3, PICO-W.15-4, U1.P$15 (GPIO11)
GPIO12: PICO-W.16-1, PICO-W.16-2, PICO-W.16-3, PICO-W.16-4, U1.P$16 (GPIO12)
GPIO13: PICO-W.17-1, PICO-W.17-2, PICO-W.17-3, PICO-W.17-4, U1.P$17 (GPIO13)
GPIO14: PICO-W.19-1, PICO-W.19-2, PICO-W.19-3, PICO-W.19-4, U1.P$18 (GPIO14)
GPIO15: PICO-W.20-1, PICO-W.20-2, PICO-W.20-3, PICO-W.20-4, U1.P$19 (GPIO15)
GPIO18: PICO-W.24-1, PICO-W.24-2, PICO-W.24-3, PICO-W.24-4, U1.P$29 (GPIO18)
GPIO19: PICO-W.25-1, PICO-W.25-2, PICO-W.25-3, PICO-W.25-4, U1.P$31 (GPIO19)
GPIO20: PICO-W.26-1, PICO-W.26-2, PICO-W.26-3, PICO-W.26-4, U1.P$32 (GPIO20)
GPIO21: PICO-W.27-1, PICO-W.27-2, PICO-W.27-3, PICO-W.27-4, U1.P$33 (GPIO21)
GPIO22: PICO-W.29-1, PICO-W.29-2, PICO-W.29-3, PICO-W.29-4, U1.P$34 (GPIO22)
GPIO23: U1.P$35 (GPIO23)
GPIO24: U1.P$36 (GPIO24)
GPIO25_LED: R9.2, U1.P$37 (GPIO25)
unnamed: C2.2, R8.1, X1.3 (XOUT)
unnamed: C3.1, R15.1, U1.P$44 (ADC_AVDD)
unnamed: R3.1, TYPE-C1.B5 (CC2)
unnamed: C17.1, R16.1, U1.P$46 (VREG_AVDD)
unnamed: R6.1, R7.2
unnamed: PICO-W.6-1, PICO-W.6-2, PICO-W.6-3, PICO-W.6-4
unnamed: PICO-W.7-1, PICO-W.7-2, PICO-W.7-3, PICO-W.7-4
unnamed: L1.P$2 (2), U1.P$48 (VREG_LX)
unnamed: R4.2, TYPE-C1.A5 (CC1)
unnamed: C5.2, R13.1, U2.3 (CHIP_EN)
unnamed: D3.+, R9.1
QSPI_SCLK: U1.P$56 (QSPI_SCLK), U3.6 (CLK)
QSPI_SD0: U1.P$57 (QSPI_SD0), U3.5 (DI(IO0))
QSPI_SD1: U1.P$59 (QSPI_SD1), U3.2 (DO(IO1))
QSPI_SD2: U1.P$58 (QSPI_SD2), U3.3 (/WP(IO2))
QSPI_SD3: U1.P$55 (QSPI_SD3), U3.7 (/HOLD(IO3))
QSPI_SS: R1.1, R2.1, U1.P$60 (QSPI_SS), U3.1 (/CS)
RESET: C14.2, PICO-W.30-1, PICO-W.30-2, PICO-W.30-3, PICO-W.30-4, R5.1, RESET.P$2 (2), U1.P$26 (RUN)
RX-DOWNLOAD: RX.P$1, U2.5 (GPIOA_8)
SWCLK: SWD.P$1, U1.P$24 (SWCLK)
SWDIO: SWD.P$3, U1.P$25 (SWD)
TX-DOWNLOAD: R6.2, TX.P$1, U2.11 (GPIOA_7)
TYPE_C_D+: P1.P$1, R10.1, TYPE-C1.A6 (DP1), TYPE-C1.B6 (DP2)
TYPE_C_D-: P2.P$1, R11.1, TYPE-C1.A7 (DN1), TYPE-C1.B7 (DN2)
USB_D+: R10.2, U1.P$52 (USB_DP)
USB_D-: R11.2, U1.P$51 (USB_DM)
VBUS: D1.A, PICO-W.40-1, PICO-W.40-2, PICO-W.40-3, PICO-W.40-4, TYPE-C1.A4 (VBUS), TYPE-C1.A9 (VBUS), TYPE-C1.B4 (VBUS), TYPE-C1.B9 (VBUS)
VSYS: C8.2, C9.2, D1.C, PICO-W.39-1, PICO-W.39-2, PICO-W.39-3, PICO-W.39-4, R14.2, U4.1 (VIN)
XIN: C1.1, U1.P$21 (XIN), X1.1 (XIN)
XOUT: R8.2, U1.P$22 (XOUT)

Notes on the sheet:
RP2350A_MCU MIN System
LED Indicator
5--3.3V
Boot:
RESET=0时，按下Boot-下载模式
Boot=1,正常运行
Type-C->USB
POWER
WIFI BLE
增加3V3_EN电路引脚引出排针
增加ADC_VREF电路引脚引出排针
删除排针GPIO4/5脚，GPIO4/5单独给BW16用
Pico W5 V0.3版本
Pico2 W5 V0.1版本
将RP2040芯片更换为RP2350A芯片
添加个别RP2350A电源3V3及1V1的部分 104电容，105电容更换为475
其他电路保持原样

Board: 2 copper layers, 51.0 x 21.0 mm, 59 parts (5 on the bottom side), 63 nets.
